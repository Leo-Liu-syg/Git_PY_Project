# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32F002Bx5,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\..\Drivers\BSP\PY32F002Bxx_Start_Kit;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\Drivers\PY32F002B_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f002b.c
    ./: startup_py32f002bxx.s
  group Application/User
    ../Src/: main.c sys.c time.c gpio.c app.c flash.c uart.c speak.c ev1527.c
  group BSP/py32f002bxx_Start_Kit
    ../../Drivers/BSP/PY32F002Bxx_Start_Kit/: py32f002bxx_ll_Start_Kit.c
  group Drivers/PY32F002B_HAL_Driver
    ../../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_ll_adc.c py32f002b_ll_gpio.c py32f002b_ll_utils.c py32f002b_ll_tim.c py32f002b_ll_usart.c py32f002b_ll_rcc.c
